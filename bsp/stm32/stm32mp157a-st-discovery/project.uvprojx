# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32MP157AACx:Cortex-M4 STMicroelectronics
  pack: Keil.STM32MP1xx_DFP.1.3.0
  cpu: IRAM(0x10020000,0x00020000) IRAM2(0x10040000,0x00020000) IROM(0x10000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000)
  output: rt-thread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CORE_CM4, __LOG_TRACE_IO_, METAL_MAX_DEVICE_REGIONS=2, VIRTIO_SLAVE_ONLY, NO_ATOMIC_64_SUPPORT, STM32MP157Axx, METAL_INTERNAL, USE_HAL_DRIVER, RT_USING_ARM_LIBC
  c include: applications;.;..\..\..\libcpu\arm\common;..\..\..\libcpu\arm\cortex-m4;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;board;board\CubeMX_Config\CM4\Inc;board\ports;..\libraries\HAL_Drivers;..\libraries\HAL_Drivers\config;..\..\..\components\finsh;.;..\..\..\include;..\..\..\components\libc\compilers\armlibc;..\..\..\components\libc\compilers\common;..\libraries\STM32MPxx_HAL\STM32MP1xx_HAL_Driver\Inc;..\libraries\STM32MPxx_HAL\CMSIS\Device\ST\STM32MP1xx\Include;..\libraries\STM32MPxx_HAL\CMSIS\Core\Include;..\libraries\STM32MPxx_HAL\CMSIS\Include
  memory RVCT4: ROM 0x10000000 size 0x40000
  memory RVCT9: RAM 0x10050000 size 0x10000
  memory RVCT10: RAM 0x0 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: main.c
  group cpu
    ../../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../../libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group DeviceDrivers
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/src/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
  group Drivers
    board/: board.c
    board/CubeMX_Config/Common/System/: system_stm32mp1xx.c
    board/CubeMX_Config/CM4/Src/: stm32mp1xx_hal_msp.c
    ../libraries/STM32MPxx_HAL/CMSIS/Device/ST/STM32MP1xx/Source/Templates/arm/: startup_stm32mp15xx.s
    ../libraries/HAL_Drivers/: drv_gpio.c drv_usart.c drv_common.c
  group finsh
    ../../../components/finsh/: shell.c cmd.c msh.c finsh_compiler.c finsh_error.c finsh_heap.c finsh_init.c finsh_node.c finsh_ops.c finsh_parser.c finsh_var.c finsh_vm.c finsh_token.c
  group Kernel
    ../../../src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c memheap.c mempool.c object.c scheduler.c signal.c thread.c timer.c
  group libc
    ../../../components/libc/compilers/armlibc/: libc.c mem_std.c stubs.c
    ../../../components/libc/compilers/common/: time.c
  group STM32_HAL
    ../libraries/STM32MPxx_HAL/STM32MP1xx_HAL_Driver/Src/: stm32mp1xx_hal.c stm32mp1xx_hal_hsem.c stm32mp1xx_hal_exti.c stm32mp1xx_hal_ipcc.c stm32mp1xx_hal_cortex.c stm32mp1xx_hal_dma.c stm32mp1xx_hal_dma_ex.c stm32mp1xx_hal_mdma.c stm32mp1xx_hal_pwr.c stm32mp1xx_hal_pwr_ex.c stm32mp1xx_hal_rcc.c stm32mp1xx_hal_rcc_ex.c stm32mp1xx_hal_gpio.c stm32mp1xx_hal_adc.c stm32mp1xx_hal_adc_ex.c stm32mp1xx_hal_dac.c stm32mp1xx_hal_dac_ex.c stm32mp1xx_hal_i2c.c stm32mp1xx_hal_i2c_ex.c stm32mp1xx_hal_spi.c stm32mp1xx_hal_tim.c stm32mp1xx_hal_tim_ex.c stm32mp1xx_hal_uart.c stm32mp1xx_hal_uart_ex.c
